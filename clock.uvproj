# Keil uVision project clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: clock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\source
  group Source Group 1
    ./: STARTUP.A51
    ./source/: main.c button.c
  group Header Group 1
    ./source/: main.h STC89C5xRC.H button.h
